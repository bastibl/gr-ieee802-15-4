<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.8.git'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transceiver_CSS_loopback</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>IEEE 802.15.4 Transceiver using CSS PHY</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>IEEE 802.15.4 Transceiver using CSS PHY</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ampl</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Noise Amplitude</value></param>
<param><key>max</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c</value></param>
<param><key>value</key><value>ieee802_15_4.css_phy(chirp_number=4, phy_packetsize_bytes=len(text_msg)+15)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>delay</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Delay</value></param>
<param><key>max</key><value>100000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>enable</value></param>
<param><key>choices</key><value>[1.0, 0.0]</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>label</key><value>TX Enable</value></param>
<param><key>labels</key><value>['on', 'off']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>button</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq_off</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>max</key><value>1e5</value></param>
<param><key>min</key><value>-1e5</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>msg_interval</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>label</key><value>Message Interval [ms]</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>pad_len</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>c.nsamp_frame*0</value></param>
<param><key>label</key><value>Pad Length</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>phi</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>np.pi/2</value></param>
<param><key>label</key><value>Phi</value></param>
<param><key>max</key><value>np.pi</value></param>
<param><key>min</key><value>-np.pi</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>text_msg</value></param>
<param><key>value</key><value>"This is a test message"</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>np.exp(1j*phi)*enable</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>ampl</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>freq_off</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>int(delay)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/tmp/sensor.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern(text_msg)</value></param>
<param><key>period</key><value>msg_interval</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>blocks_vector_insert_x_0</value></param>
<param><key>offset</key><value>3*c.nsamp_frame</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>3*c.nsamp_frame</value></param>
<param><key>vector</key><value>[0 for i in range(pad_len)]</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>tech</key><value>127</value></param>
</block>
<block>
<key>ieee802_15_4_css_phy</key>
<param><key>id</key><value>ieee802_15_4_css_phy_1</value></param>
<param><key>bits_per_cw</key><value>c.bits_per_symbol</value></param>
<param><key>chirp_seq</key><value>c.chirp_seq</value></param>
<param><key>codewords</key><value>c.codewords</value></param>
<param><key>intlv_seq</key><value>c.intlv_seq</value></param>
<param><key>nzeros_padding</key><value>c.padded_zeros</value></param>
<param><key>nbytes_payload</key><value>c.phy_packetsize_bytes</value></param>
<param><key>num_subchirps</key><value>c.n_subchirps</value></param>
<param><key>phr</key><value>c.PHR</value></param>
<param><key>preamble</key><value>c.preamble</value></param>
<param><key>sfd</key><value>c.SFD</value></param>
<param><key>nsamp_frame</key><value>c.nsamp_frame</value></param>
<param><key>len_sub</key><value>38</value></param>
<param><key>sym_per_frame</key><value>c.nsym_frame</value></param>
<param><key>threshold</key><value>0.95</value></param>
<param><key>time_gap_1</key><value>c.time_gap_1</value></param>
<param><key>time_gap_2</key><value>c.time_gap_2</value></param>
</block>
<block>
<key>ieee802_15_4_mac</key>
<param><key>id</key><value>ieee802_15_4_mac_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>ieee802_15_4_rime_stack</key>
<param><key>id</key><value>ieee802_15_4_rime_stack_0</value></param>
<param><key>bc_channels</key><value>[129]</value></param>
<param><key>rime_add</key><value>[23,42]</value></param>
<param><key>ruc_channels</key><value>[132]</value></param>
<param><key>uc_channels</key><value>[131]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import ieee802_15_4</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb</value></param>
<param><key>labels</key><value>['RX Waterfall', 'RX FFT', 'RX Time', 'RX Symbols']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>you can connect to the Socket PDU with: 'nc -u localhost 52002'</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>nb, 1</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>RX FFT</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_2</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>nb, 2</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>RX Time Signal</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_3</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>nb,3</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>RX Correlator Output</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>nb,0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>RX Waterfall</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>ieee802_15_4_css_phy_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>wxgui_scopesink2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>strobe</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_vector_insert_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>pdus</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>blocks_vector_insert_x_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_css_phy_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_15_4_css_phy_1</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>rxout</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_css_phy_1</source_block_id><sink_block_id>wxgui_scopesink2_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>app out</source_key><sink_key>fromMAC</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>pdu out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>ieee802_15_4_css_phy_1</sink_block_id><source_key>pdu out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>bcout</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>toMAC</source_key><sink_key>app in</sink_key></connection>
</flow_graph>
