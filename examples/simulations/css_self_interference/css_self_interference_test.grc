<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>i2</value></param>
<param><key>value</key><value>ieee802_15_4.css_phy(slow_rate=False, chirp_number=3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>enable</value></param>
<param><key>value</key><value>[0.0, 0.0, 0.0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>snr</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c</value></param>
<param><key>value</key><value>ieee802_15_4.css_phy(slow_rate=False, chirp_number=1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>i1</value></param>
<param><key>value</key><value>ieee802_15_4.css_phy(slow_rate=False, chirp_number=2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>i3</value></param>
<param><key>value</key><value>ieee802_15_4.css_phy(slow_rate=False, chirp_number=4)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import ieee802_15_4</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1.1507</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>foo_periodic_msg_source</key>
<param><key>id</key><value>foo_periodic_msg_source_0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.PMT_NIL, pmt.string_to_symbol("trigger"))</value></param>
<param><key>interval</key><value>100</value></param>
<param><key>quit</key><value>True</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>num</key><value>-1</value></param>
</block>
<block>
<key>ieee802_15_4_make_pair_with_blob</key>
<param><key>id</key><value>ieee802_15_4_make_pair_with_blob_0_2</value></param>
<param><key>vec</key><value>np.random.randint(0,256,(c.phy_packetsize_bytes,))</value></param>
</block>
<block>
<key>ieee802_15_4_css_phy_tx_only</key>
<param><key>id</key><value>ieee802_15_4_css_phy_tx_only_0</value></param>
<param><key>time_gap_2</key><value>i1.time_gap_2</value></param>
<param><key>nzeros_padding</key><value>i1.padded_zeros</value></param>
<param><key>sym_per_frame</key><value>i1.nsym_frame</value></param>
<param><key>time_gap_1</key><value>i1.time_gap_1</value></param>
<param><key>phr</key><value>i1.PHR</value></param>
<param><key>nsamp_frame</key><value>i1.nsamp_frame</value></param>
<param><key>preamble</key><value>i1.preamble</value></param>
<param><key>num_subchirps</key><value>i1.n_subchirps</value></param>
<param><key>len_sub</key><value>38</value></param>
<param><key>chirp_seq</key><value>i1.chirp_seq</value></param>
<param><key>nbytes_payload</key><value>i1.phy_packetsize_bytes</value></param>
<param><key>bits_per_cw</key><value>i1.bits_per_symbol</value></param>
<param><key>codewords</key><value>i1.codewords</value></param>
<param><key>intlv_seq</key><value>i1.intlv_seq</value></param>
<param><key>sfd</key><value>i1.SFD</value></param>
</block>
<block>
<key>ieee802_15_4_make_pair_with_blob</key>
<param><key>id</key><value>ieee802_15_4_make_pair_with_blob_0_0</value></param>
<param><key>vec</key><value>np.random.randint(0,256,(c.phy_packetsize_bytes,))</value></param>
</block>
<block>
<key>ieee802_15_4_make_pair_with_blob</key>
<param><key>id</key><value>ieee802_15_4_make_pair_with_blob_0_1</value></param>
<param><key>vec</key><value>np.random.randint(0,256,(c.phy_packetsize_bytes,))</value></param>
</block>
<block>
<key>ieee802_15_4_css_phy_tx_only</key>
<param><key>id</key><value>ieee802_15_4_css_phy_tx_only_0_1</value></param>
<param><key>time_gap_2</key><value>i2.time_gap_2</value></param>
<param><key>nzeros_padding</key><value>i2.padded_zeros</value></param>
<param><key>sym_per_frame</key><value>i2.nsym_frame</value></param>
<param><key>time_gap_1</key><value>i2.time_gap_1</value></param>
<param><key>phr</key><value>i2.PHR</value></param>
<param><key>nsamp_frame</key><value>i2.nsamp_frame</value></param>
<param><key>preamble</key><value>i2.preamble</value></param>
<param><key>num_subchirps</key><value>i2.n_subchirps</value></param>
<param><key>len_sub</key><value>38</value></param>
<param><key>chirp_seq</key><value>i2.chirp_seq</value></param>
<param><key>nbytes_payload</key><value>i2.phy_packetsize_bytes</value></param>
<param><key>bits_per_cw</key><value>i2.bits_per_symbol</value></param>
<param><key>codewords</key><value>i2.codewords</value></param>
<param><key>intlv_seq</key><value>i2.intlv_seq</value></param>
<param><key>sfd</key><value>i2.SFD</value></param>
</block>
<block>
<key>ieee802_15_4_css_phy_tx_only</key>
<param><key>id</key><value>ieee802_15_4_css_phy_tx_only_0_0</value></param>
<param><key>time_gap_2</key><value>i3.time_gap_2</value></param>
<param><key>nzeros_padding</key><value>i3.padded_zeros</value></param>
<param><key>sym_per_frame</key><value>i3.nsym_frame</value></param>
<param><key>time_gap_1</key><value>i3.time_gap_1</value></param>
<param><key>phr</key><value>i3.PHR</value></param>
<param><key>nsamp_frame</key><value>i3.nsamp_frame</value></param>
<param><key>preamble</key><value>i3.preamble</value></param>
<param><key>num_subchirps</key><value>i3.n_subchirps</value></param>
<param><key>len_sub</key><value>38</value></param>
<param><key>chirp_seq</key><value>i3.chirp_seq</value></param>
<param><key>nbytes_payload</key><value>i3.phy_packetsize_bytes</value></param>
<param><key>bits_per_cw</key><value>i3.bits_per_symbol</value></param>
<param><key>codewords</key><value>i3.codewords</value></param>
<param><key>intlv_seq</key><value>i3.intlv_seq</value></param>
<param><key>sfd</key><value>i3.SFD</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>ieee802_15_4_css_phy_self_interference</value></param>
<param><key>title</key><value>IEEE 802.15.4 CSS PHY Self-Interference Test</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>description</key><value>IEEE 802.15.4 CSS PHY Self-Interference Test</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>0.5*(10**(-snr/20))</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>ieee802_15_4_css_phy_sd</key>
<param><key>id</key><value>ieee802_15_4_css_phy_0</value></param>
<param><key>phr</key><value>c.PHR</value></param>
<param><key>nbytes_payload</key><value>c.phy_packetsize_bytes</value></param>
<param><key>bits_per_cw</key><value>c.bits_per_symbol</value></param>
<param><key>codewords</key><value>c.codewords</value></param>
<param><key>intlv_seq</key><value>c.intlv_seq</value></param>
<param><key>sym_per_frame</key><value>c.nsym_frame</value></param>
<param><key>num_subchirps</key><value>c.n_subchirps</value></param>
<param><key>chirp_seq</key><value>c.chirp_seq</value></param>
<param><key>time_gap_1</key><value>c.time_gap_1</value></param>
<param><key>time_gap_2</key><value>c.time_gap_2</value></param>
<param><key>len_sub</key><value>38</value></param>
<param><key>nzeros_padding</key><value>c.padded_zeros</value></param>
<param><key>preamble</key><value>c.preamble</value></param>
<param><key>sfd</key><value>c.SFD</value></param>
<param><key>nsamp_frame</key><value>c.nsamp_frame</value></param>
</block>
<block>
<key>ieee802_15_4_make_pair_with_blob</key>
<param><key>id</key><value>ieee802_15_4_make_pair_with_blob_0</value></param>
<param><key>vec</key><value>np.random.randint(0,256,(c.phy_packetsize_bytes,))</value></param>
</block>
<block>
<key>ieee802_15_4_compare_blobs</key>
<param><key>id</key><value>ieee802_15_4_compare_blobs_0</value></param>
<param><key>packet_error_mode</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>enable[0]</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>enable[1]</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>enable[2]</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_css_phy_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>ieee802_15_4_make_pair_with_blob_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_make_pair_with_blob_0</source_block_id><sink_block_id>ieee802_15_4_css_phy_0</sink_block_id><source_key>out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>ieee802_15_4_css_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_15_4_css_phy_tx_only_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_css_phy_tx_only_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_css_phy_tx_only_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>ieee802_15_4_make_pair_with_blob_0_2</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>ieee802_15_4_make_pair_with_blob_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>ieee802_15_4_make_pair_with_blob_0_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_make_pair_with_blob_0_2</source_block_id><sink_block_id>ieee802_15_4_css_phy_tx_only_0</sink_block_id><source_key>out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_make_pair_with_blob_0_0</source_block_id><sink_block_id>ieee802_15_4_css_phy_tx_only_0_0</sink_block_id><source_key>out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_make_pair_with_blob_0_1</source_block_id><sink_block_id>ieee802_15_4_css_phy_tx_only_0_1</sink_block_id><source_key>out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_css_phy_0</source_block_id><sink_block_id>ieee802_15_4_compare_blobs_0</sink_block_id><source_key>rxout</source_key><sink_key>test</sink_key></connection>
<connection><source_block_id>ieee802_15_4_make_pair_with_blob_0</source_block_id><sink_block_id>ieee802_15_4_compare_blobs_0</sink_block_id><source_key>out</source_key><sink_key>ref</sink_key></connection>
</flow_graph>
