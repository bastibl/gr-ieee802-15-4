<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ieee802_15_4_css_phy</value></param>
<param><key>title</key><value>IEEE 802.15.4 CSS PHY</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>description</key><value>IEEE 802.15.4 CSS (Chirp Spread Spectrum) physical layer</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>IEEE802.15.4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phr</value></param>
<param><key>label</key><value>PHR</value></param>
<param><key>value</key><value>[0 for i in range(12)]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nbytes_payload</value></param>
<param><key>label</key><value>Num payload bytes</value></param>
<param><key>value</key><value>127</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>txin</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>ieee802_15_4_fragmentation</key>
<param><key>id</key><value>ieee802_15_4_fragmentation_0</value></param>
<param><key>nbytes</key><value>nbytes_payload</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>ieee802_15_4_phr_prefixer_c</key>
<param><key>id</key><value>ieee802_15_4_phr_prefixer_c_0</value></param>
<param><key>phr</key><value>phr</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ieee802_15_4_fragmentation_0</sink_block_id><source_key>0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_fragmentation_0</source_block_id><sink_block_id>ieee802_15_4_phr_prefixer_c_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_phr_prefixer_c_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
