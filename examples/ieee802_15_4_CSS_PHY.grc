<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ieee802_15_4_css_phy</value></param>
<param><key>title</key><value>IEEE 802.15.4 CSS PHY</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>description</key><value>IEEE 802.15.4 CSS PHY</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>IEEE802.15.4</value></param>
</block>
<block>
<key>ieee802_15_4_codeword_mapper_bi</key>
<param><key>id</key><value>ieee802_15_4_codeword_mapper_bi_0</value></param>
<param><key>bits_per_cw</key><value>bits_per_cw</value></param>
<param><key>codewords</key><value>codewords</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sfd</value></param>
<param><key>label</key><value>SFD</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>codewords</value></param>
<param><key>label</key><value>Codewords</value></param>
<param><key>value</key><value>[[0,0],[1,1]]</value></param>
</block>
<block>
<key>ieee802_15_4_zeropadding_b</key>
<param><key>id</key><value>ieee802_15_4_zeropadding_b_0</value></param>
<param><key>nzeros</key><value>nzeros_padding</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chirp_seq</value></param>
<param><key>label</key><value>Chirp sequence</value></param>
<param><key>value</key><value>[]</value></param>
</block>
<block>
<key>foo_burst_tagger</key>
<param><key>id</key><value>foo_burst_tagger_0</value></param>
<param><key>tag_name</key><value>pmt.intern("burst_len")</value></param>
<param><key>mult</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>time_gap_1</value></param>
<param><key>label</key><value>Time gap 1</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_sub</value></param>
<param><key>label</key><value>Samples per subchirp</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nzeros_padding</value></param>
<param><key>label</key><value>Num padded zeros</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>time_gap_2</value></param>
<param><key>label</key><value>Time gap 2</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bits_per_cw</value></param>
<param><key>label</key><value>Bits per codeword</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>intlv_seq</value></param>
<param><key>label</key><value>Interleaver sequence</value></param>
<param><key>value</key><value>[]</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>packet_len</key><value>nsamp_frame</value></param>
<param><key>len_tag_key</key><value>"burst_len"</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble</value></param>
<param><key>label</key><value>Preamble</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>txout</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_subchirps</value></param>
<param><key>label</key><value>Num subchirps per sequence</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nbytes_payload</value></param>
<param><key>label</key><value>Num payload bytes</value></param>
<param><key>value</key><value>127</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>ieee802_15_4_codeword_mapper_bi</key>
<param><key>id</key><value>ieee802_15_4_codeword_mapper_bi_0_0</value></param>
<param><key>bits_per_cw</key><value>bits_per_cw</value></param>
<param><key>codewords</key><value>codewords</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phr</value></param>
<param><key>label</key><value>PHR</value></param>
<param><key>value</key><value>[0 for i in range(12)]</value></param>
</block>
<block>
<key>ieee802_15_4_interleaver_ii</key>
<param><key>id</key><value>ieee802_15_4_interleaver_ii_0</value></param>
<param><key>intlv_seq</key><value>intlv_seq</value></param>
<param><key>forward</key><value>1</value></param>
</block>
<block>
<key>ieee802_15_4_preamble_sfd_prefixer_ii</key>
<param><key>id</key><value>ieee802_15_4_preamble_sfd_prefixer_ii_0</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>sfd</key><value>sfd</value></param>
<param><key>nsym_frame</key><value>sym_per_frame</value></param>
</block>
<block>
<key>ieee802_15_4_interleaver_ii</key>
<param><key>id</key><value>ieee802_15_4_interleaver_ii_0_0</value></param>
<param><key>intlv_seq</key><value>intlv_seq</value></param>
<param><key>forward</key><value>1</value></param>
</block>
<block>
<key>ieee802_15_4_preamble_sfd_prefixer_ii</key>
<param><key>id</key><value>ieee802_15_4_preamble_sfd_prefixer_ii_0_0</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>sfd</key><value>sfd</value></param>
<param><key>nsym_frame</key><value>sym_per_frame</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nsamp_frame</value></param>
<param><key>label</key><value>Samples per frame</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>long</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sym_per_frame</value></param>
<param><key>label</key><value>Symbols per frame</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>ieee802_15_4_dqpsk_mapper_ff</key>
<param><key>id</key><value>ieee802_15_4_dqpsk_mapper_ff_0</value></param>
<param><key>framelen</key><value>sym_per_frame</value></param>
<param><key>forward</key><value>1</value></param>
</block>
<block>
<key>ieee802_15_4_codeword_soft_demapper_fb</key>
<param><key>id</key><value>ieee802_15_4_codeword_soft_demapper_fb_0</value></param>
<param><key>bits_per_cw</key><value>bits_per_cw</value></param>
<param><key>codewords</key><value>codewords</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>m</key><value>sym_per_frame-len(preamble)-len(sfd)</value></param>
<param><key>n</key><value>sym_per_frame</value></param>
<param><key>offset</key><value>len(preamble)+len(sfd)</value></param>
</block>
<block>
<key>ieee802_15_4_deinterleaver_ff</key>
<param><key>id</key><value>ieee802_15_4_deinterleaver_ff_0_0</value></param>
<param><key>intlv_seq</key><value>intlv_seq</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>ieee802_15_4_zeropadding_removal_b</key>
<param><key>id</key><value>ieee802_15_4_zeropadding_removal_b_0_0</value></param>
<param><key>phr_payload_len</key><value>nbytes_payload*8+len(phr)</value></param>
<param><key>nzeros</key><value>nzeros_padding</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>m</key><value>sym_per_frame-len(preamble)-len(sfd)</value></param>
<param><key>n</key><value>sym_per_frame</value></param>
<param><key>offset</key><value>len(preamble)+len(sfd)</value></param>
</block>
<block>
<key>ieee802_15_4_codeword_soft_demapper_fb</key>
<param><key>id</key><value>ieee802_15_4_codeword_soft_demapper_fb_0_0</value></param>
<param><key>bits_per_cw</key><value>bits_per_cw</value></param>
<param><key>codewords</key><value>codewords</value></param>
</block>
<block>
<key>ieee802_15_4_deinterleaver_ff</key>
<param><key>id</key><value>ieee802_15_4_deinterleaver_ff_0</value></param>
<param><key>intlv_seq</key><value>intlv_seq</value></param>
</block>
<block>
<key>ieee802_15_4_phr_removal</key>
<param><key>id</key><value>ieee802_15_4_phr_removal_0_0</value></param>
<param><key>phr</key><value>phr</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_0</value></param>
<param><key>label</key><value>rxout</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>post_costas_iq.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>post_costas_abs.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>ieee802_15_4_preamble_tagger_cc</key>
<param><key>id</key><value>ieee802_15_4_preamble_tagger_cc_0</value></param>
<param><key>len_preamble</key><value>len(preamble)</value></param>
</block>
<block>
<key>ieee802_15_4_dqpsk_soft_demapper_cc</key>
<param><key>id</key><value>ieee802_15_4_dqpsk_soft_demapper_cc_0</value></param>
<param><key>framelen</key><value>sym_per_frame</value></param>
</block>
<block>
<key>ieee802_15_4_frame_buffer_cc</key>
<param><key>id</key><value>ieee802_15_4_frame_buffer_cc_0</value></param>
<param><key>nsym_frame</key><value>sym_per_frame</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>np.exp(1j*np.pi/4)</value></param>
</block>
<block>
<key>ieee802_15_4_qpsk_mapper_if</key>
<param><key>id</key><value>ieee802_15_4_qpsk_mapper_if_0</value></param>
</block>
<block>
<key>ieee802_15_4_dqcsk_mapper_fc</key>
<param><key>id</key><value>ieee802_15_4_dqcsk_mapper_fc_0</value></param>
<param><key>chirp_seq</key><value>chirp_seq</value></param>
<param><key>time_gap_1</key><value>time_gap_1</value></param>
<param><key>time_gap_2</key><value>time_gap_2</value></param>
<param><key>len_subchirp</key><value>len_sub</value></param>
<param><key>num_subchirps</key><value>num_subchirps</value></param>
<param><key>nsym_frame</key><value>sym_per_frame</value></param>
</block>
<block>
<key>ieee802_15_4_fragmentation</key>
<param><key>id</key><value>ieee802_15_4_fragmentation_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>nbytes</key><value>nbytes_payload</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>txin</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>ieee802_15_4_phr_prefixer_c</key>
<param><key>id</key><value>ieee802_15_4_phr_prefixer_c_0</value></param>
<param><key>phr</key><value>phr</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>rxin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ieee802_15_4_costas_loop_cc</key>
<param><key>id</key><value>ieee802_15_4_costas_loop_cc_0</value></param>
<param><key>constellation_points</key><value>(1+1j, -1+1j, -1-1j, 1-1j)</value></param>
<param><key>initial_index</key><value>-1</value></param>
</block>
<block>
<key>ieee802_15_4_multiuser_chirp_detector_cc</key>
<param><key>id</key><value>ieee802_15_4_multiuser_chirp_detector_cc_0</value></param>
<param><key>chirp_seq</key><value>chirp_seq</value></param>
<param><key>time_gap_1</key><value>len(time_gap_1)</value></param>
<param><key>time_gap_2</key><value>len(time_gap_2)</value></param>
<param><key>len_subchirp</key><value>len_sub</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>ieee802_15_4_simple_chirp_detector_cc</key>
<param><key>id</key><value>ieee802_15_4_simple_chirp_detector_cc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>chirp_seq</key><value>chirp_seq</value></param>
<param><key>time_gap_1</key><value>len(time_gap_1)</value></param>
<param><key>time_gap_2</key><value>len(time_gap_2)</value></param>
<param><key>len_subchirp</key><value>len_sub</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>pre_costas_arg.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>qpsk_tx.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>post_sync_arg.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>qpsk_rx.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<connection><source_block_id>foo_burst_tagger_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>foo_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_dqcsk_mapper_fc_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_interleaver_ii_0</source_block_id><sink_block_id>ieee802_15_4_preamble_sfd_prefixer_ii_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_preamble_sfd_prefixer_ii_0</source_block_id><sink_block_id>ieee802_15_4_qpsk_mapper_if_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_interleaver_ii_0_0</source_block_id><sink_block_id>ieee802_15_4_preamble_sfd_prefixer_ii_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_preamble_sfd_prefixer_ii_0_0</source_block_id><sink_block_id>ieee802_15_4_qpsk_mapper_if_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_15_4_qpsk_mapper_if_0</source_block_id><sink_block_id>ieee802_15_4_dqpsk_mapper_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>ieee802_15_4_fragmentation_0</sink_block_id><source_key>0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_dqpsk_mapper_ff_0</source_block_id><sink_block_id>ieee802_15_4_dqcsk_mapper_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_codeword_mapper_bi_0_0</source_block_id><sink_block_id>ieee802_15_4_interleaver_ii_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_codeword_mapper_bi_0</source_block_id><sink_block_id>ieee802_15_4_interleaver_ii_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>ieee802_15_4_codeword_mapper_bi_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>ieee802_15_4_codeword_mapper_bi_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_zeropadding_b_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_phr_prefixer_c_0</source_block_id><sink_block_id>ieee802_15_4_zeropadding_b_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_fragmentation_0</source_block_id><sink_block_id>ieee802_15_4_phr_prefixer_c_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0_0</source_block_id><sink_block_id>ieee802_15_4_zeropadding_removal_b_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_codeword_soft_demapper_fb_0</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_15_4_codeword_soft_demapper_fb_0_0</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_deinterleaver_ff_0</source_block_id><sink_block_id>ieee802_15_4_codeword_soft_demapper_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_deinterleaver_ff_0_0</source_block_id><sink_block_id>ieee802_15_4_codeword_soft_demapper_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0</source_block_id><sink_block_id>ieee802_15_4_deinterleaver_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0_0</source_block_id><sink_block_id>ieee802_15_4_deinterleaver_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_phr_removal_0_0</source_block_id><sink_block_id>pad_sink_1_0</sink_block_id><source_key>out</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_zeropadding_removal_b_0_0</source_block_id><sink_block_id>ieee802_15_4_phr_removal_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_frame_buffer_cc_0</source_block_id><sink_block_id>ieee802_15_4_dqpsk_soft_demapper_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0_0</source_block_id><sink_block_id>blocks_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_costas_loop_cc_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_costas_loop_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_costas_loop_cc_0</source_block_id><sink_block_id>ieee802_15_4_preamble_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_preamble_tagger_cc_0</source_block_id><sink_block_id>ieee802_15_4_frame_buffer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_dqpsk_soft_demapper_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_arg_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_qpsk_mapper_if_0</source_block_id><sink_block_id>blocks_file_sink_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ieee802_15_4_simple_chirp_detector_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_simple_chirp_detector_cc_0</source_block_id><sink_block_id>ieee802_15_4_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_simple_chirp_detector_cc_0</source_block_id><sink_block_id>blocks_complex_to_arg_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>ieee802_15_4_phr_prefixer_c_0</sink_block_id><source_key>0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ieee802_15_4_multiuser_chirp_detector_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_frame_buffer_cc_0</source_block_id><sink_block_id>blocks_complex_to_arg_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_multiuser_chirp_detector_cc_0</source_block_id><sink_block_id>blocks_complex_to_arg_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_multiuser_chirp_detector_cc_0</source_block_id><sink_block_id>ieee802_15_4_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
