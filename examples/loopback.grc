<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import sin, pi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>gr_message_strobe</key>
<param><key>id</key><value>gr_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.pmt_intern("Hello World!\n")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>gr_socket_pdu</key>
<param><key>id</key><value>gr_socket_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
<param><key>host</key><value></value></param>
<param><key>port</key><value>52001</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>ieee802_15_4_rime_framer</key>
<param><key>id</key><value>ieee802_15_4_rime_framer_0</value></param>
</block>
<block>
<key>gr_packed_to_unpacked_xx</key>
<param><key>id</key><value>gr_packed_to_unpacked_xx_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>4</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>gr_chunks_to_symbols_xx</key>
<param><key>id</key><value>gr_chunks_to_symbols_xx_0_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>[(1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j)]</value></param>
<param><key>dimension</key><value>16</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>gr_socket_pdu</key>
<param><key>id</key><value>gr_socket_pdu_0_0</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
<param><key>host</key><value></value></param>
<param><key>port</key><value>52002</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>ieee802_15_4_rime_deframer</key>
<param><key>id</key><value>ieee802_15_4_rime_deframer_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>ieee802_15_4_mac_deframer</key>
<param><key>id</key><value>ieee802_15_4_mac_deframer_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/wireshark.fifo</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>ieee802_15_4_wireshark_connector</key>
<param><key>id</key><value>ieee802_15_4_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_15_4_packet_sink</key>
<param><key>id</key><value>ieee802_15_4_packet_sink_0</value></param>
<param><key>th</key><value>10</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>omega</key><value>5</value></param>
<param><key>gain_omega</key><value>0.000225</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>0.03</value></param>
<param><key>omega_relative_limit</key><value>0.0002</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.00016</value></param>
</block>
<block>
<key>gr_sub_xx</key>
<param><key>id</key><value>gr_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>gr_quadrature_demod_cf</key>
<param><key>id</key><value>gr_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>[0, sin(pi/4), 1, sin(3*pi/4)]</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>gr_delay</key>
<param><key>id</key><value>gr_delay_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>2</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_float</key>
<param><key>id</key><value>gr_complex_to_float_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interp</key><value>4</value></param>
</block>
<block>
<key>gr_float_to_complex</key>
<param><key>id</key><value>gr_float_to_complex_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>ieee802_15_4_mac_framer</key>
<param><key>id</key><value>ieee802_15_4_mac_framer_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<connection><source_block_id>ieee802_15_4_rime_framer_0</source_block_id><sink_block_id>ieee802_15_4_mac_framer_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gr_packed_to_unpacked_xx_0_0_0</source_block_id><sink_block_id>gr_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_framer_0</source_block_id><sink_block_id>gr_packed_to_unpacked_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_socket_pdu_0</source_block_id><sink_block_id>ieee802_15_4_rime_framer_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gr_message_strobe_0</source_block_id><sink_block_id>ieee802_15_4_rime_framer_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_deframer_0</source_block_id><sink_block_id>ieee802_15_4_rime_deframer_0</sink_block_id><source_key>pdu out</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_deframer_0</source_block_id><sink_block_id>gr_socket_pdu_0_0</sink_block_id><source_key>pdu out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_15_4_packet_sink_0</source_block_id><sink_block_id>ieee802_15_4_mac_deframer_0</sink_block_id><source_key>out</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_packet_sink_0</source_block_id><sink_block_id>ieee802_15_4_wireshark_connector_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>ieee802_15_4_packet_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_quadrature_demod_cf_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_quadrature_demod_cf_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>gr_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_float_to_complex_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>gr_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_float_0</source_block_id><sink_block_id>gr_delay_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_delay_0</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_complex_to_float_0</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
